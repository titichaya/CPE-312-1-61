# Keil uVision project STM32L152-TNI.uvprojx, settings and files
target Workspace (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32L152RB STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.2.0
  cpu: IRAM(0x20000000,0x00004000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32L152-TNI +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_FULL_LL_DRIVER,STM32L152xB
  c include: ..\inc;..\..\..\Drivers\STM32L1xx_HAL_Driver\Inc;..\..\..\Drivers\CMSIS\Device\ST\STM32L1xx\Include;..\..\..\Drivers\CMSIS\Include;..\..\..\Drivers\BSP\STM32L152C-Discovery;..\..\..\RTE
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group CMSIS
    ../src/: system_stm32l1xx.c
    ../../../Drivers/CMSIS/Device/ST/STM32L1xx/Source/Templates/arm/: startup_stm32l152xb.s
  group Drivers
    ../src/: stm32l1xx_ll_lcd.c
    ../../../Drivers/STM32L1xx_HAL_Driver/Src/: stm32l1xx_ll_gpio.c stm32l1xx_ll_pwr.c stm32l1xx_ll_rcc.c stm32l1xx_ll_utils.c stm32l1xx_ll_tim.c stm32l1xx_ll_exti.c stm32l1xx_ll_usart.c stm32l1xx_ll_spi.c
  group User
    ../src/: stm32l1xx_it.c main.c stm32l152_glass_lcd.c
  group New Group
    ../../../RTX/: RTX_Conf_CM.c
