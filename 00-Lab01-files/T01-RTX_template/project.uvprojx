# Keil uVision project project.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32L152RB STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.2.0
  cpu: IRAM(0x20000000,0x00004000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: project
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER STM32L1XX_MD
  c include: .\CMSIS\Include;.\CMSIS\Device\ST\STM32L1xx\Include;.\StdPeriph;.\StdPeriph\inc;.\StdPeriph\src;.\USER
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group USER
    ./USER/: switch_led.c
  group StdPeriph
    ./StdPeriph/src/: stm32l1xx_gpio.c stm32l1xx_rcc.c
software components: CMSIS:CORE 5.0.0, Device:Startup 2.0.0
